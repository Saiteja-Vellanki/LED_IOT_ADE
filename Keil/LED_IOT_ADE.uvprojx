# Keil uVision project LED_IOT_ADE.uvprojx, settings and files
target LED_IOT_ADE (6240000::V6.24::ARMCLANG)
  device: NUC029LAN Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) IROM2(0x00100000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: LED_IOT_ADE
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUC029xAN\Include;..\..\..\Library\StdDriver\inc;..\..\..\SampleCode\LED_IOT_ADE\Keil
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_NUC029xAN.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC029xAN/Source/ARM/: startup_NUC029xAN.s
    ../../../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c
  group User
    ../: main.c
  group Switch
    ./: switch.h switch.c
software components: CMSIS:CORE 6.2.0
